# Keil uVision project 贪吃蛇.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(33000000) MODAT2
  output: 贪吃蛇 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: gui.c R61505V.c 贪吃蛇.c
