# Keil uVision project top51.uvproj, settings and files
target 目标 1 (MCS-51)
  device: AT89S51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(33000000) MODAT2
  output: top51 +hex
  c flags: Optimize=8 SizeSpeed=1
  group 源程序组 1
    ./: delay.c top51.c snake.c key_sweep.c
    ./GUI/: gui.c
    ./LCM/: ILI9325.c
