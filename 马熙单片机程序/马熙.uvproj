# Keil uVision project 马熙.uvproj, settings and files
target 目标 1 (MCS-51)
  device: AT89S51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(33000000) MODAT2
  output: 马熙 +hex
  c flags: Optimize=8 SizeSpeed=1
  group 源代码组 1
    ./: 马熙.c
